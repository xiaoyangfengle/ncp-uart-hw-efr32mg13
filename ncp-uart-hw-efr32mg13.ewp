# IAR project ncp-uart-hw-efr32mg13.ewp, settings and files
configuration Normal (ARM, debug)
  General.OGChipSelectEditMenu: EFR32MG13P732F512GM48 SiliconLaboratories EFR32MG13P732F512GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STA_GECKO_INFO_PAGE_BTL; CORTEXM3; CORTEXM3_EFR32; CORTEXM3_EFR32_MICRO; CORTEXM3_EFM32_MICRO; EFR32_SERIES1_CONFIG3_MICRO; EFR32MG13P; EFR32MG13P732F512GM48; CONFIGURATION_HEADER="ncp-configuration.h"; PLATFORM_HEADER="platform/base/hal/micro/cortexm3/compiler/iar.h"; __SOURCEFILE__="$FILE_FNAME$"; HAL_CONFIG=1; EMBER_AF_USE_HWCONF; EMBER_AF_NCP; EMBER_STACK_ZIGBEE; USE_SIMEE2; EZSP_UART; NO_USB; EMLIB_USER_CONFIG; EMBER_SERIAL1_MODE=EMBER_SERIAL_BUFFER; EMBER_SERIAL1_TX_QUEUE_SIZE=2; EMBER_SERIAL1_RX_QUEUE_SIZE=64; EMBER_SERIAL1_RTSCTS; EMBER_SERIAL0_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL0_TX_QUEUE_SIZE=64; EMBER_SERIAL0_RX_QUEUE_SIZE=64; APPLICATION_TOKEN_HEADER="ncp-token.h"; APPLICATION_MFG_TOKEN_HEADER="ncp-mfg-token.h"; PHY_RAIL=1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\protocol\zigbee\app\ncp; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\protocol\zigbee\app\ncp\..\..; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\protocol\zigbee\app\ncp\..\..\stack; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\protocol\zigbee\app\ncp\..\util; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\plugin; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\..; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\micro\cortexm3\efm32; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\micro\cortexm3\efm32\config; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\micro\cortexm3\efm32\efr32; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\..\..\CMSIS\Include; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\..\..\Device\SiliconLabs-Restricted\efr32mg13p\Include; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\..\..\Device\SiliconLabs\efr32mg13p\Include; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\..\..\emdrv\common\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\..\..\emdrv\config; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\..\..\emdrv\dmadrv\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\..\..\emdrv\gpiointerrupt\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\..\..\emdrv\rtcdrv\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\..\..\emdrv\sleep\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\..\..\emdrv\spidrv\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\..\..\emdrv\tempdrv\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\..\..\emdrv\uartdrv\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\..\..\emdrv\ustimer\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\..\..\emlib\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\..\..\middleware\glib; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\..\..\middleware\glib\glib; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\..\..\radio\rail_lib\plugin; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\common\cortex; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\rfprotocol\ieee802154\cortex; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\halconfig\inc\hal-config; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\hardware\module\config; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\hardware\kit\common\halconfig; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\hardware\kit\common\bsp; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\radio\rail_lib\chip\efr32\efr32xg1x; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\radio\rail_lib\protocol\zwave; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\radio\rail_lib\protocol\ieee802154; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\radio\rail_lib\protocol\ble; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\radio\rail_lib\common; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\radio\rail_lib\plugin\coexistence\hal\efr32; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\radio\rail_lib\plugin\coexistence\protocol\ieee802154; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\radio\rail_lib\plugin\coexistence\common; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\bootloader; hal-config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: STA_GECKO_INFO_PAGE_BTL; CORTEXM3; CORTEXM3_EFM32_MICRO; CORTEXM3_EFR32_MICRO; CORTEXM3_EFR32; EFR32_SERIES1_CONFIG3_MICRO; EFR32MG13P; EFR32MG13P732F512GM48; CONFIGURATION_HEADER="ncp-configuration.h"; PLATFORM_HEADER="platform/base/hal/micro/cortexm3/compiler/iar.h"; HAL_CONFIG=1; EMBER_AF_USE_HWCONF; EMBER_AF_NCP; EMBER_STACK_ZIGBEE; USE_SIMEE2; EZSP_UART; NO_USB; EMLIB_USER_CONFIG; EMBER_SERIAL1_MODE=EMBER_SERIAL_BUFFER; EMBER_SERIAL1_TX_QUEUE_SIZE=2; EMBER_SERIAL1_RX_QUEUE_SIZE=64; EMBER_SERIAL1_RTSCTS; EMBER_SERIAL0_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL0_TX_QUEUE_SIZE=64; EMBER_SERIAL0_RX_QUEUE_SIZE=64; APPLICATION_TOKEN_HEADER="ncp-token.h"; APPLICATION_MFG_TOKEN_HEADER="ncp-mfg-token.h"; PHY_RAIL=1
  AARM.AUserIncludes: $FILE_DIR$; $PROJ_DIR$; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\protocol\zigbee\app\ncp; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\protocol\zigbee\app\ncp\..\..; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\protocol\zigbee\app\ncp\..\..\stack; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\protocol\zigbee\app\ncp\..\util; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\plugin; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\..; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\micro\cortexm3\efm32; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\micro\cortexm3\efm32\config; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\micro\cortexm3\efm32\efr32; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\..\..\CMSIS\Include; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\..\..\Device\SiliconLabs-Restricted\efr32mg13p\Include; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\..\..\Device\SiliconLabs\efr32mg13p\Include; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\..\..\emdrv\common\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\..\..\emdrv\config; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\..\..\emdrv\dmadrv\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\..\..\emdrv\gpiointerrupt\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\..\..\emdrv\rtcdrv\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\..\..\emdrv\rtcdrv\test; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\..\..\emdrv\sleep\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\..\..\emdrv\spidrv\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\..\..\emdrv\tempdrv\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\..\..\emdrv\uartdrv\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\..\..\emdrv\ustimer\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\..\..\emlib\inc; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\..\..\middleware\glib; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\..\..\middleware\glib\glib; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\common\cortex; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\rfprotocol\ieee802154\cortex; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\halconfig\inc\hal-config; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\hardware\kit\common\halconfig; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\hardware\kit\common\bsp; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\radio\rail_lib\chip\efr32\efr32xg1x; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\radio\rail_lib\protocol\zwave; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\radio\rail_lib\protocol\ieee802154; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\radio\rail_lib\protocol\ble; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\radio\rail_lib\common; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\radio\rail_lib\plugin\coexistence\hal\efr32; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\radio\rail_lib\plugin\coexistence\protocol\ieee802154; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\radio\rail_lib\plugin\coexistence\common; ..\..\..\..\..\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\bootloader; hal-config
  OBJCOPY.OOCOutputFile: ncp-uart-hw-efr32mg13.s37
  prebuild: ncp-uart-hw-efr32mg13-prebuild.bat '$TARGET_BPATH$' '$PROJ_DIR$' '$TOOLKIT_DIR$' 'C:\SiliconLabs\SimplicityStudio\v4'
  postbuild: ncp-uart-hw-efr32mg13-postbuild.bat '$TARGET_BPATH$' '$PROJ_DIR$' '$TOOLKIT_DIR$' 'C:\SiliconLabs\SimplicityStudio\v4'
  ILINK.IlinkOutputFile: ncp-uart-hw-efr32mg13.out
  ILINK.IlinkConfigDefines: FLASH_SIZE=524288; RAM_SIZE=65536; SIMEEPROM_SIZE=36864; LOCKBITS_IN_MAINFLASH_SIZE=0; STA_GECKO_INFO_PAGE_BTL=1; EMBER_MALLOC_HEAP_SIZE=0
  ILINK.IlinkIcfFile: C:\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.5\platform\base\hal/micro/cortexm3/efm32/iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group emdrv
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/platform/base/hal/../../emdrv/dmadrv/src/: dmadrv.c
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/platform/base/hal/../../emdrv/gpiointerrupt/src/: gpiointerrupt.c
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/platform/base/hal/../../emdrv/rtcdrv/src/: rtcdriver.c
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/platform/base/hal/../../emdrv/sleep/src/: sleep.c
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/platform/base/hal/../../emdrv/tempdrv/src/: tempdrv.c
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/platform/base/hal/../../emdrv/ustimer/src/: ustimer.c
  group emlib
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/platform/base/hal/../../emlib/src/: em_adc.c em_cmu.c em_core.c em_emu.c em_gpio.c em_i2c.c em_ldma.c em_leuart.c em_msc.c em_prs.c em_rmu.c em_rtcc.c em_system.c em_timer.c em_usart.c em_wdog.c
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/platform/base/hal/../../Device/SiliconLabs/EFR32MG13P/Source/: system_efr32mg13p.c
  group adc
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/platform/base/hal/plugin/adc/: adc-efr32.c
  group antenna-stub
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/platform/base/hal/plugin/antenna-stub/: antenna-stub.c
  group button-stub
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/platform/base/hal/micro/generic/: button-stub.c
  group buzzer-stub
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/platform/base/hal/plugin/buzzer-stub/: buzzer-stub.c
  group coexistence
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/platform/radio/rail_lib/plugin/coexistence/protocol/ieee802154/: coexistence-802154.c
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/platform/radio/rail_lib/plugin/coexistence/common/: coexistence.c
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/platform/radio/rail_lib/plugin/coexistence/hal/efr32/: coexistence-directional-priority.c coexistence-hal.c
  group debug-basic-library
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/platform/base/hal/plugin/debug/rtt/: SEGGER_RTT.c
  group debug-channel
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/platform/base/hal/plugin/debug-jtag/: debug-jtag-efr32.c
  group diagnostic
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/platform/base/hal/micro/cortexm3/efm32/: diagnostic.c
  group ember-minimal-printf
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/platform/base/hal/plugin/serial/: ember-printf.c
  group hal-library
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/platform/base/hal/micro/cortexm3/efm32/: assert-crash-handlers.c cstartup-common.c faults-v7m.s79 hal-config.c hal-config-gpio.c isr-stubs.s79 mfg-token.c micro-common.c micro.c mpu.c sleep-efm32.c token.c
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/platform/base/hal/micro/generic/: crc.c endian.c mem-util.c random.c token-def.c
  group led
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/platform/base/hal/micro/cortexm3/efm32/: led.c
  group ncp-uart
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/protocol/zigbee/app/em260/: em260-common.c serial-interface-uart.c
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/protocol/zigbee/stack/config/: ember-configuration.c
  group secure-ezsp-stub
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/protocol/zigbee/app/util/ezsp/: secure-ezsp-stub.c
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/protocol/zigbee/app/em260/: command-handlers-secure-ezsp-stub.c
  group serial
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/platform/base/hal/plugin/serial/: serial.c
  group sim-eeprom2
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/platform/base/hal/plugin/sim-eeprom2/: sim-eeprom2.c
  group Generated
    ./: ncp-bookkeeping.c ncp-events.c ezsp-command-handler.c ncp-callback-stubs.c ncp-callbacks.c
  group Additional
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/platform/base/hal/micro/cortexm3/efm32/: bootloader-interface.c bootloader-interface-standalone.c
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/platform/bootloader/api/: btl_interface.c
    ./: ezsp-command-handler.c
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/platform/base/hal/plugin/serial/cortexm/efm32/: com.c
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/platform/emdrv/uartdrv/src/: uartdrv.c
  group Libraries
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/platform/radio/rail_lib/autogen/librail_release/: librail_efr32xg13_iar_release.a
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/protocol/zigbee/build/binding-table-library-cortexm3-iar-efr32mg13p-rail/: binding-table-library.a
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/protocol/zigbee/build/cbke-163k1-stub-library-cortexm3-iar-efr32mg13p-rail/: cbke-163k1-stub-library.a
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/protocol/zigbee/build/cbke-283k1-stub-library-cortexm3-iar-efr32mg13p-rail/: cbke-283k1-stub-library.a
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/protocol/zigbee/build/cbke-library-dsa-sign-stub-cortexm3-iar-efr32mg13p-rail/: cbke-library-dsa-sign-stub.a
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/protocol/zigbee/build/cbke-library-dsa-verify-283k1-stub-cortexm3-iar-efr32mg13p-rail/: cbke-library-dsa-verify-283k1-stub.a
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/protocol/zigbee/build/cbke-library-dsa-verify-stub-cortexm3-iar-efr32mg13p-rail/: cbke-library-dsa-verify-stub.a
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/protocol/zigbee/build/cbke-stub-library-cortexm3-iar-efr32mg13p-rail/: cbke-stub-library.a
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/protocol/zigbee/build/debug-basic-library-cortexm3-iar-efr32mg13p-rail/: debug-basic-library.a
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/protocol/zigbee/build/debug-extended-library-cortexm3-iar-efr32mg13p-rail/: debug-extended-library.a
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/protocol/zigbee/build/em260-concentrator-library-cortexm3-iar-efr32mg13p-rail/: em260-concentrator-library.a
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/protocol/zigbee/build/em260-uart-util-library-cortexm3-iar-efr32mg13p-rail/: em260-uart-util-library.a
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/protocol/zigbee/build/em260-xncp-stub-library-cortexm3-iar-efr32mg13p-rail/: em260-xncp-stub-library.a
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/protocol/zigbee/build/end-device-bind-library-cortexm3-iar-efr32mg13p-rail/: end-device-bind-library.a
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/protocol/zigbee/build/gp-library-cortexm3-iar-efr32mg13p-rail/: gp-library.a
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/protocol/zigbee/build/hal-library-cortexm3-iar-efr32mg13p-rail/: hal-library.a
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/protocol/zigbee/build/install-code-library-cortexm3-iar-efr32mg13p-rail/: install-code-library.a
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/protocol/zigbee/build/mfglib-library-cortexm3-iar-efr32mg13p-rail/: mfglib-library.a
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/protocol/zigbee/build/multi-network-stub-library-cortexm3-iar-efr32mg13p-rail/: multi-network-stub-library.a
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/protocol/zigbee/build/ncp-ash-buffers-rts-cts-library-cortexm3-iar-efr32mg13p-rail/: ncp-ash-buffers-rts-cts-library.a
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/protocol/zigbee/build/ncp-binding-library-cortexm3-iar-efr32mg13p-rail/: ncp-binding-library.a
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/protocol/zigbee/build/ncp-cbke-library-cortexm3-iar-efr32mg13p-rail/: ncp-cbke-library.a
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/protocol/zigbee/build/ncp-gp-library-cortexm3-iar-efr32mg13p-rail/: ncp-gp-library.a
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/protocol/zigbee/build/ncp-mfglib-library-cortexm3-iar-efr32mg13p-rail/: ncp-mfglib-library.a
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/protocol/zigbee/build/ncp-pro-library-cortexm3-iar-efr32mg13p-rail/: ncp-pro-library.a
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/protocol/zigbee/build/ncp-security-library-cortexm3-iar-efr32mg13p-rail/: ncp-security-library.a
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/protocol/zigbee/build/ncp-zll-library-cortexm3-iar-efr32mg13p-rail/: ncp-zll-library.a
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/protocol/zigbee/build/packet-validate-library-cortexm3-iar-efr32mg13p-rail/: packet-validate-library.a
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/protocol/zigbee/build/security-library-core-cortexm3-iar-efr32mg13p-rail/: security-library-core.a
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/protocol/zigbee/build/security-library-link-keys-cortexm3-iar-efr32mg13p-rail/: security-library-link-keys.a
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/protocol/zigbee/build/sim-eeprom2-1to2-upgrade-stub-library-cortexm3-iar-efr32mg13p-rail/: sim-eeprom2-1to2-upgrade-stub-library.a
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/protocol/zigbee/build/sim-eeprom2-library-cortexm3-iar-efr32mg13p-rail/: sim-eeprom2-library.a
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/protocol/zigbee/build/zigbee-pro-stack-cortexm3-iar-efr32mg13p-rail/: zigbee-pro-stack.a
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/protocol/zigbee/build/zigbee-r22-support-stub-library-cortexm3-iar-efr32mg13p-rail/: zigbee-r22-support-stub-library.a
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.5/protocol/zigbee/build/zll-library-cortexm3-iar-efr32mg13p-rail/: zll-library.a
